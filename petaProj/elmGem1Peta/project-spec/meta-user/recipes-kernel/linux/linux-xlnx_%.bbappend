SRC_URI += "file://user_2021-04-20-18-33-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

